# Keil uVision project ftm_simple_pwm.uvprojx, settings and files
target ftm_simple_pwm debug (6150000::V6.15::ARMCLANG)
  device: MKE17Z256VLH7 NXP
  pack: NXP.MKE17Z7_DFP.15.0.0
  cpu: IRAM(0x1fffc000,0xc000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ftm_simple_pwm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_MKE17Z256VLL7, FRDM_KE17Z, FREEDOM, MCUXPRESSO_SDK
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;CMSIS;component/lists;component/uart;device;.\drivers;frdmke17z/driver_examples/ftm/simple_pwm;utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0xc000
  scatter file: MKE17Z7/arm/MKE17Z256xxx7_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MKE17Z7.h MKE17Z7_features.h system_MKE17Z7.c system_MKE17Z7.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h
    ./drivers/: fsl_lptmr.c
  group source
    source/: ftm_simple_pwm.c
  group startup
    startup/: startup_MKE17Z7.S
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
target ftm_simple_pwm release (6150000::V6.15::ARMCLANG)
  device: MKE17Z256VLL7 NXP
  pack: NXP.MKE17Z7_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: ftm_simple_pwm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_MKE17Z256VLL7, FRDM_KE17Z, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: board;CMSIS;component/lists;component/uart;device;drivers;frdmke17z/driver_examples/ftm/simple_pwm;utilities
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: MKE17Z7/arm/MKE17Z256xxx7_flash.scf
  link misc: as above
